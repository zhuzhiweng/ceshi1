# Keil uVision project EOBD.uvprojx, settings and files
target EOBD-2G (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;..\User;..\Bsp;..\Diagnose;..\Formula;..\Proj;..\hardware;.\RTE\CMSIS;..\utils;..\utils;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\hardware\WKUP;..\GPS;..\GB17691;..\NetManage;..\OBD;..\Lib\n32g45x_std_periph_driver\inc;..\Lib\CMSIS\CM3\DeviceSupport\NA\N32G45x
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group User
    ../User/: main.c TerminalTest.c stm32f10x_it.c user_config.h
  group OBD
    ../OBD/: can.c iso_15765.c j_1939.c obd.c CanDataAnalysis.c UDS.c
  group DRIVER
    ../hardware/: spi_flash.c
  group GB17691
    ../GB17691/: GB17691_CAN_GPS.c GB17691A.c
  group GPS
    ../GPS/: GPS_calculation.c gps.c
  group NetManage
    ../NetManage/: crc.c sim_pwrkey.c sim_uart.c sim_net.c MultiSocket.h multiSocket.c
  group HARDWARE
    ../Bsp/: Bsp.c
    ../hardware/: SPI.c UART.c dma.c timer.c iwdg.c rtc.c power_ctl.c sleep.c LKT4305_IIC.c
    ../hardware/WKUP/: wkup.c
  group Lib
    ../Lib/n32g45x_std_periph_driver/src/: n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_dbg.c n32g45x_dma.c n32g45x_rtc.c n32g45x_exti.c n32g45x_gpio.c n32g45x_iwdg.c n32g45x_spi.c n32g45x_tim.c n32g45x_usart.c n32g45x_xfmc.c misc.c n32g45x_rcc.c n32g45x_pwr.c
  group utils
    ../utils/: utils.c
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 1.0.0, Device:System_N32G45x 1.0.0
